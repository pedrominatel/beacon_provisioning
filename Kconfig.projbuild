## Kconfig.projbuild
```kconfig
menu "Beacon Provisioning"
    menu "Default Configuration"

    endmenu
endmenu
```
